# Keil uVision project midi.uvprojx, settings and files
target Target (6220000::V6.22::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: midi +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER,NDEBUG
  c include: ..\..\DRIVER\FWLIB;..\..\DRIVER\FWLIB\inc;..\..\DRIVER\CMSIS;..\..\DRIVER\BSP
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group DRIVER/CMSIS
    ../../DRIVER/CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_ld.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group DRIVER/FWLIB
    ../../DRIVER/FWLIB/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../DRIVER/FWLIB/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../../DRIVER/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DRIVER/BSP
    ../../DRIVER/BSP/: led.c led.h pwm.c pwm.h serial.c serial.h
  group USER
    ../../USER/: main.c delay.c delay.h midi.c midi.h
